SRC_URI += "file://user_2019-02-15-14-23-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

